## sys/net_benchmark/Kconfig
```kconfig
config MODULE_NET_BENCHMARK
    bool "Benchmarking module"
    depends on TEST_KCONFIG
```
